Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2025-03-18T15:16:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.1.367 - Exporter 22.0.1.367 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 18 15:16:50 2025 * Host: DESKTOP-BHLRMPQ * Database: C:\Users\NICKDE~1\AppData\Local\Temp\9b04c2f6-6d25-4b5f-b360-5a5d786ab398\8c638123-0aa3-47c7-a689-7f070d64fcef\ifc * Database version: 5507 * Database creation date: Tue Mar 18 15:16:48 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 18 15:16:48 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 18 15:16:48 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcBuildingElementProxy: Family1:Standard, Family1:Standard:207222
In: Level 1
Type - Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Aux_Diameter: 20 mm; Backup_water_Diameter: 14 mm; Connector_16_Diameter: 40 mm; Waste_Diameter: 44.3 mm; WC_Diameter: 20 mm; WM_Diameter: 20 mm
Type - Identity Data - Type Name: Standard
Type - Other - Category: Generic Models; Family Name: Family1
Type - Pset_ProductRequirements - Category: Generic Models
Material: Default, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 5.57777 m2; Volume: 0.984594 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction

# IfcDistributionPort (8)
Description: Flow
Name | FlowDirection
2 x Port_207222 | SINK
2 x Port_207222 | SOURCEANDSINK
4 x Port_207222 | SOURCE
